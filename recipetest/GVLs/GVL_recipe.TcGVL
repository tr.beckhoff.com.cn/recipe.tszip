VAR_GLOBAL
	velocity:LREAL;
	distance:LREAL;
	version:STRING;
	number:INT;
	boxL:LREAL;
	boxW:LREAL;
	boxH:LREAL;
END_VAR
